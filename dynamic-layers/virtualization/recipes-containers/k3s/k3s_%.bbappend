BIN_PREFIX = "${exec_prefix}"

INSANE_SKIP:${PN}:append = " textrel"
