PACKAGE_INSTALL:intel-corei7-64 += "ipxe"
