TOOLCHAIN = "gcc"
# EXTRA_OEMAKE += "LD=ld.bfd"
# EXTRA_OEMAKE += "--trace SHELL='bash -x'"
